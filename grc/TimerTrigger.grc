options:
  parameters:
    author: Jaden Keener
    generate_options: no_gui
    id: timertrigger
    output_language: python
    title: Timer Trigger
  states: {}

blocks:
- name: iono_window
  id: variable
  parameters:
    value: (fs/slope)*1.5
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    short_id: D
    type: intx
    value: '9000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"TimerTrigger_epy_block_0.py\nLast Edited 5/4/24\nBy Jaden Keener and the NMT Dev Team\n\nFirst custom block of the ChirpRX DSP chain.\nCreates a local timer that records a received Ionosonde signal. \nTimer length and recording window are specified by user input parameters.\n\nCalls LocalChirp.py after recording is complete.\n\"\"\"\n\n# Imports\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport datetime \nimport os\n\n\"\"\" blk definition\nThis is the standard block class declaration for use in gnu radio. \nThis file is one custom block in the larger TimerTrigger.py flowchart\n\nSee gnu radio 'custom py block' documentation for further explanation.\n\"\"\"\nclass blk(gr.basic_block):  \n    \n    def __init__(\n        self, \n        hour=0, \n        min=0, \n        sec=0, \n        capture_window = 10, \n        ionosonde_period = 12, \n        samp_rate=12.5E6, \n        slope = 100E3, \n        decimation=5e3, \n        offset=0,\n        fc=14.25E6):  \n    \n        gr.basic_block.__init__(\n            self,\n            name='Timer Trigger 1.1',  \n            in_sig=[np.complex64],\n            out_sig=None\n        )\n        \n        \"\"\" Add parameters to class instance \"\"\"\n        self.hour = hour\n        self.min = min\n        self.sec = sec\n        self.capture_window = capture_window\n        self.iono_per = ionosonde_period\n        self.samp_rate = samp_rate\n        self.slope = slope\n        self.decimation = decimation\n        self.fc = fc\n        self.offset = offset\n\n        \"\"\" Calculate inital timer start time\n        This is the first time the timer will trigger.  We must convert\n        the HH:MM:SS user input to the correct unix time.  Assumes that the\n        time given is today.\n        \n        If the time given is in the past, forward calculate to the next future\n        time based on the given period.\n        \"\"\"\n        timeTuple = time.localtime()\n        timeList = list(timeTuple)\n        timeList[3] = self.hour\n        timeList[4] = self.min\n        timeList[5] = self.sec\n        timeTuple = tuple(timeList)\n        self.startTime = time.mktime(timeTuple)\n        \n        # Make sure we are in the present\n        while self.startTime <= time.time():\n            self.startTime = self.startTime + self.iono_per*60\n        \n        # Set a writing flag\n        self.writing = False\n        \n    \n    \"\"\" work function\n    Standard declaration for gnu radio work function.  This is the function\n    that is called whenever gnu radio has samples for this block to process.  \n    \n    This function is not called for every sample individually, but is instead\n    fed large batches of samples at once.\n    \"\"\"\n    def general_work(self, input_items, output_items):\n    \n        \"\"\" Wait and write\n        This if/elif statement controls the timer and data capture. \n        If the writing flag is true, then we write whatever samples we have \n        gathered to disk and check if time is up. If time is up, then close the\n        file and call LocalChirp.py\n        \n        If the writing flag isnt active, we check to see if we the timer has\n        'gone off' and we should set it to true.\n        \"\"\"\n        if self.writing:\n            self.file.write(input_items[0][:])\n            if time.time() >= self.startTime + self.capture_window:\n                self.writing = False\n                self.file.close()\n                self.startTime = (\n                                    time.time() \n                                    + self.iono_per*60\n                                    -self.capture_window\n                                )\n                print(\"Stop Writing, Running LocalChirp at \"\n                      +time.strftime(\"%H:%M:%S\"))\n                os.system(\"python3 LocalChirp.py\"\n                          +\" -P \"+str(self.filename)\n                          +\" -W \"+str(self.capture_window)\n                          +\" -D \"+str(self.decimation)\n                          +\" -M \"+str(self.slope)\n                          +\" -C \"+str(self.fc)\n                          +\" -O \"+str(self.offset)\n                          +\" -B \"+str(self.samp_rate))\n        elif time.time() >= self.startTime:\n            self.writing = True\n            self.filename = './RAW/{date:%Y%m%d_%H%M%S}.RAW'.format(date=datetime.datetime.now())\n            print(\"Writing to \"+self.filename)\n            self.file = open(self.filename, \"ab\")\n            self.file.write(input_items[0][:])\n        \n        \n        self.consume(0, len(input_items[0]))  # GNU radio boilerplate\n        return 0                              # GNU radio boilerplate\n\n"
    capture_window: iono_window
    decimation: decimation
    fc: fc
    hour: hour
    ionosonde_period: iono_per
    min: minute
    offset: (msoffset*1E-3)*slope
    samp_rate: fs
    sec: second
    slope: slope
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Center Frequency
    short_id: C
    type: eng_float
    value: 14.25E6
  states: {}
- name: fs
  id: parameter
  parameters:
    label: Sample Frequency
    short_id: B
    type: eng_float
    value: 12.5E6
  states: {}
- name: hour
  id: parameter
  parameters:
    label: Hour for trigger
    short_id: H
    type: intx
    value: '0'
  states: {}
- name: iono_per
  id: parameter
  parameters:
    label: Ionosonde Period (in M)
    short_id: T
    type: eng_float
    value: '12'
  states: {}
- name: minute
  id: parameter
  parameters:
    label: Minute for trigger
    short_id: M
    type: intx
    value: '0'
  states: {}
- name: msoffset
  id: parameter
  parameters:
    label: ms offset
    short_id: O
    type: eng_float
    value: '0'
  states: {}
- name: second
  id: parameter
  parameters:
    label: Second for trigger
    short_id: S
    type: intx
    value: '0'
  states: {}
- name: slope
  id: parameter
  parameters:
    label: Ionosonde Slope
    short_id: P
    type: eng_float
    value: 100E3
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: B
    bw0: fs
    center_freq0: fc
    gain0: '50'
    samp_rate: fs
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
