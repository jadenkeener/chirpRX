options:
  parameters:
    author: Jaden Keener
    generate_options: no_gui
    id: LocalChirp
    output_language: python
    run_options: run
    title: localChirp
  states: {}

blocks:
- name: fftsz
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: filt_cutoff
  id: variable
  parameters:
    value: samp_rate/decimation*0.8
  states: {}
- name: filt_transwidth
  id: variable
  parameters:
    value: (samp_rate/decimation - filt_cutoff) *2
  states: {}
- name: outfile
  id: variable
  parameters:
    value: path.split(".")[0] + ".chirp"
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: path
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*length)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    short_id: D
    type: intx
    value: '9000'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Local Chirp
      By Jaden Keener, Last updated 5/3/23

      Generates a local tone that sweeps the spectrum at the specified slope

      """

      import numpy as np
      import pmt
      from gnuradio import gr
      import os
      import time


      class blk(gr.sync_block):  

          def __init__(self, slope=100e3, samp_rate=200e6/12, offset = 10e3, filename=None, decimation=100, fc = 14.25E6):
              gr.sync_block.__init__(
                  self,
                  name='Local Chirp 1.6',   
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.slope = slope  
              self.fs = samp_rate
              self.fc = fc
              self.offset = offset
              self.filename = filename
              self.decimation = decimation
              self.over = True
              
              self.lastT = 0
              self.lastF = -self.fs/2 + self.offset
              self.spanF = self.lastF + self.fs/2 - self.offset
              self.dt = 1/self.fs
              self.df = self.slope/self.fs/2 #why /2 ?? I have no idea, but it has to be
              # over 2 has something to do with span of f not being -fs/2 to fs/2 but
              # just fs..???
              
              
              self.controlPortName = 'controlIn'
              self.message_port_register_in(pmt.intern(self.controlPortName))
              self.set_msg_handler(pmt.intern(self.controlPortName), self.handle_msg)
              self.control = False
              
                  
              
          def handle_msg(self, msg):
              controlIn = pmt.to_bool(msg)
              
              if controlIn > self.controlLast+self.trigger_Power:
                  self.control = True
              
              self.controlLast = controlIn
              
          def work(self, input_items, output_items):
          
              # Find number of samples on this call
              n = len(input_items[0]) 

              # If we havent progged the whole spectrum
              if self.lastF <= self.offset/2: # WHY OFFSET/2 ??????????? IDK
              
                  # Calculate the values of T and F we prog to on this call
                  newT = self.dt*n + self.lastT
                  newF = self.df*n + self.lastF
                  
                  # Make sure arrays are correct size. Can get slightly offsize due
                  # to float precision errors
                  t = np.resize(np.arange(self.lastT, newT, self.dt), n)
                  f = np.resize(np.arange(self.lastF, newF, self.df), n)
                  
                  # Output is a complex exponential (I/Q)
                  output_items[0][:] = np.exp(1j*2*np.pi*f*t)
                  
                  # Update bookmarks
                  self.lastT = newT
                  self.lastF = newF
              
              # Otherwise call ionogrammer_lite
              else:
                  
                  output_items[0][:] = input_items[0] * 0;
                  if self.over:
                      print("Locally Chirped at "+time.strftime("%H:%M:%S"))
                      os.system("python3 ionogrammer_lite.py"
                                +" -p "+str(self.filename)
                                +" -P "+str(self.slope)
                                +" -B "+str(self.fs)
                                +" -C "+str(self.fc)
                                +" -d "+str(self.decimation))
                      self.over = False
                  
              return len(output_items[0])
    decimation: decimation
    fc: fc
    filename: outfile
    offset: '0'
    samp_rate: samp_rate
    slope: slope
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: C
    type: eng_float
    value: 14.25E6
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: filt_cutoff
    decim: decimation
    gain: '1'
    nthreads: '8'
    samp_rate: samp_rate
    type: ccc
    width: filt_transwidth
    win: window.WIN_HAMMING
  states: {}
- name: length
  id: parameter
  parameters:
    label: Capture Length (s)
    short_id: W
    type: eng_float
    value: '150'
  states: {}
- name: path
  id: parameter
  parameters:
    label: File Path
    short_id: P
    type: str
    value: None
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fftsz
    name: '"Raw Rec"'
    plotconst: 'False'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Raw"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Filtered"'
    type: complex
    update_time: decimation/samp_rate/1024
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: B
    type: eng_float
    value: 12.5e6
  states: {}
- name: slope
  id: parameter
  parameters:
    label: Ionosodne Slope
    short_id: M
    type: eng_float
    value: 100E3
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_head_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_head_0, '0', epy_block_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [epy_block_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
