options:
  parameters:
    author: Jaden Keener
    generate_options: no_gui
    id: timertrigger
    output_language: python
    title: Timer Trigger
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 8e6+samp_rate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6/16
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Real Timer Trigger
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import datetime 
      import os



      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          
          def __init__(self, hour=0, min=0, sec=0, capture_window = 10, ionosonde_period = 12, samp_rate=12.5E6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Real Timer Trigger',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.hour = hour
              self.min = min
              self.sec = sec
              self.capture_window = capture_window
              self.iono_per = ionosonde_period
              self.samp_rate = samp_rate
              #self.portName_fileName = 'File Name'
              #self.message_port_register_out(pmt.intern(self.portName_fileName))
              
              # Calculate start time in unix
              timeTuple = time.localtime()
              timeList = list(timeTuple)
              timeList[3] = self.hour
              timeList[4] = self.min
              timeList[5] = self.sec
              timeTuple = tuple(timeList)
              self.startTime = time.mktime(timeTuple)
              
              # Make sure we are in the present
              while self.startTime <= time.time():
                  self.startTime = self.startTime + self.iono_per*60
              
              self.writing = False
              
              
          def general_work(self, input_items, output_items):
              if self.writing:
                  self.file.write(input_items[0][:])
                  if time.time() >= self.startTime + self.capture_window:
                      self.writing = False
                      self.file.close()
                      self.startTime = time.time() + self.iono_per*60-self.capture_window
                      print("Stop Writing, Running LocalChirp")
                      os.system("python3 LocalChirp.py -p "+str(self.filename)+" -l "+str(self.capture_window)+" -s "+str(self.samp_rate))
                      
                      
              elif time.time() >= self.startTime:
                  self.writing = True
                  self.filename = '{date:%Y%m%d_%H%M%S}.RAW'.format(date=datetime.datetime.now())
                  print("Writing to "+self.filename)
                  self.file = open(self.filename, "ab")
                  self.file.write(input_items[0][:])
              
              
              self.consume(0, len(input_items[0]))
              return 0
    capture_window: '10'
    hour: '0'
    ionosonde_period: '0.5'
    min: '0'
    samp_rate: '12500000.0'
    sec: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Local Chirp
      By Jaden Keener, Last updated 3/27/23

      Generates a local tone that sweeps the spectrum at the specified slope

      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  

          def __init__(self, slope=100e3, samp_rate=200e6/12, offset = 10e3):
              gr.sync_block.__init__(
                  self,
                  name='Local Chirp Test 1.0',   
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.slope = slope  
              self.fs = samp_rate
              self.offset = offset
              self.debug = False
              
              self.lastT = 0
              self.lastF = -self.fs/2 + self.offset
              self.spanF = self.lastF + self.fs/2 - self.offset
              self.dt = 1/self.fs
              self.df = self.slope/self.fs/2 #why /2 ?? I have no idea, but it has to be
              # over 2 has something to do with span of f not being -fs/2 to fs/2 but
              # just fs..???
              
              
              self.controlPortName = 'controlIn'
              self.message_port_register_in(pmt.intern(self.controlPortName))
              self.set_msg_handler(pmt.intern(self.controlPortName), self.handle_msg)
              self.control = False
              
                  
              
          def handle_msg(self, msg):
              controlIn = pmt.to_bool(msg)
              
              if controlIn > self.controlLast+self.trigger_Power:
                  self.control = True
              
              self.controlLast = controlIn
              
          def work(self, input_items, output_items):
          
              # Find number of samples on this call
              n = len(input_items[0]) 

              # If we havent progged the whole spectrum
              if self.lastF <= self.offset/2: # WHY OFFSET/2 ??????????? IDK
              
                  # Calculate the values of T and F we prog to on this call
                  newT = self.dt*n + self.lastT
                  newF = self.df*n + self.lastF
                  
                  # Make sure arrays are correct size. Can get slightly offsize due
                  # to float precision errors
                  t = np.resize(np.arange(self.lastT, newT, self.dt), n)
                  f = np.resize(np.arange(self.lastF, newF, self.df), n)
                  
                  # Output is a complex exponential (I/Q)
                  output_items[0][:] = np.exp(1j*2*np.pi*f*t)
                  
                  # Update bookmarks
                  self.lastT = newT
                  self.lastF = newF
              
              # Otherwise do nothing
              else:
                  output_items[0][:] = input_items[0] * 0;
                  if self.debug:
                      self.debug = False
                      raise ValueError(self.lastF)
                  
              
              return len(output_items[0])
    offset: '0'
    samp_rate: samp_rate
    slope: 100e3
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: B
    bw0: samp_rate
    center_freq0: fc
    clock_source0: gpsdo
    gain0: '50'
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', epy_block_1, '0']
- [blocks_throttle_0_0, '0', uhd_usrp_source_0, command]
- [epy_block_1, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
