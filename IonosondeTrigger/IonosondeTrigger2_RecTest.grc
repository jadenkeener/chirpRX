options:
  parameters:
    generate_options: qt_gui
    id: Itrigger2_virtual
    output_language: python
    title: Trigger Virtual
  states: {}

blocks:
- name: fftsz
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: 1e3
  states: {}
- name: movavg_length
  id: variable_qtgui_range
  parameters:
    label: Moving Average Length
    start: '1000'
    step: '1'
    stop: '16383'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '10'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsz
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: movavg_length
    max_iter: '4000'
    scale: 1/movavg_length
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fftsz
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fftsz
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsz
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: 32e3
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    FFT_size: fftsz
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import math
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, FFT_size=1024, sample_rate=25E6, frequency_low=10.9e6,
                      frequency_high=11.1e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Selective FFT Vdector Averager',   # will show up in GRC
                  in_sig=[(np.float32,FFT_size)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.FFT_size = FFT_size
              self.sample_rate = sample_rate
              self.frequency_low = frequency_low+sample_rate/2
              self.frequency_high = frequency_high+sample_rate/2
              
              # Calculate the bins we are interested in sampling
              self.bin_width = (self.sample_rate)/self.FFT_size
              self.bin_low = math.floor(self.frequency_low/self.bin_width)
              self.bin_high = math.floor(self.frequency_high/self.bin_width)
              print("tesT")

          def general_work(self, input_items, output_items):
              # Loop through all received vectors
              print("Input: ", len(input_items[0]))
              for i in range(len(input_items[0])-1):
                  output_items[0][i] = input_items[0][i][self.bin_low:self.bin_high].mean()
              print("Output: ", len(output_items[0]))
              print("-----------------------")
              
              #consoooom
              self.consume(0, len(input_items[0]))
              
              return len(output_items[0])
    frequency_high: 5.1e3
    frequency_low: 4.9e3
    sample_rate: samp_rate
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """ Ionosonde Trigger Block
          By Jaden Keener, 2/5/23
          
          Last updated 2/12/23 12:55
          - Added moving average functionality. Now we shouldn't have to manually set
            trigger threshold
          
          This block records the raw SDR output when a strong enough input is 
          provided. This block is meant to be used alongside a filter. The filter 
          should bandpass the trigger frequency, then go to an average power block
          which then feeds into this blocks first input.
          
          Outputs are purely debug.
          
          See __init__ for additional i/o information
      """

      import numpy as np
      import datetime
      from gnuradio import gr

      class blk(gr.sync_block):  

          def __init__(self, trigger_delta_dB=5, samp_rate = 32E3, capture_window = 5): 
              
              """ INPUTS/OUTPUTS:
                      input[0]: Signal average power
                      input[1]: Raw data from SDR
                      input[2]: Moving average of [0]
                      
                      output[0]: debug state information
                      output[1]: debug timer information
                  """
              gr.sync_block.__init__(
                  self,
                  name='Ionosonde Trigger 2.0', 
                  in_sig=[np.float32, np.complex64],
                  out_sig=[np.float32, np.float32]
              )
              
              self.trigger_Power = trigger_delta_dB
              self.samp_rate = samp_rate
              self.capture_window = capture_window
              # timer max is calculated as sample rate * capture window in seconds.
              self.timerMax = self.timer = self.samp_rate * self.capture_window
              self.writing = False
             

          def work(self, input_items, output_items):
              print("Trigger in: ", len(input_items[1]))
              self.power_movavg = 30
              
              # Check if we are writing
              if self.writing:
                  # If we are and we still have time on the clock
                  if self.timer < self.timerMax:
                      # Then write data to file
                      self.file.write(input_items[1][:])
                      self.timer += len(input_items[1])
                      output_items[0][:] = 2
                  else:
                      # Otherwise close the file and reset flags
                      self.file.close()
                      self.writing = False
                      output_items[0][:] = 0
              
              # If not writing, do we have high power on trigger?
              elif np.any(input_items[0] > self.trigger_Power+self.power_movavg):
                  # Set status variables
                  self.writing = True
                  self.timer = 0
                  output_items[0][:] = 1
                  
                  # Open new file and do first write
                  self.filename = '{date:%Y%m%d_%H%M%S}.chirp'.format(date=datetime.datetime.now())
                  self.file = open(self.filename, "ab")
                  self.file.write(input_items[1][:])
              # Show debug state of none
              else:
                  output_items[0][:] = 0
              
              # For debugging timer
              output_items[1][:] = self.timer
              
              # gnuradio needs this return
              return len(output_items[0])
    capture_window: '10'
    samp_rate: samp_rate
    trigger_delta_dB: '300'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsz
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsz)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    name: '"Power"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '3'
    name: '"TrigOut"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: 200E3
    min: '0'
    name: '"Timer"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Moving Average"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Raw"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    ref_level: '1'
    vlen: fftsz
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: selected_fft
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: selected_fft
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_1, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_2_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_1, '0', epy_block_1_0, '0']
- [blocks_throttle_1, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', virtual_sink_1, '0']
- [epy_block_1_0, '0', qtgui_number_sink_1_0, '0']
- [epy_block_1_0, '1', qtgui_number_sink_1_1_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [virtual_source_0_0, '0', epy_block_1_0, '1']
- [virtual_source_1_0, '0', blocks_moving_average_xx_0_0, '0']
- [virtual_source_1_0, '0', epy_block_1_0, '0']
- [virtual_source_1_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
