options:
  parameters:
    generate_options: qt_gui
    id: Itrigger2_sdr
    output_language: python
    title: Trigger SDR
  states: {}

blocks:
- name: filter_width
  id: variable_qtgui_range
  parameters:
    label: Filter Width
    start: '500'
    step: '500'
    stop: 100E3
    value: 10E3
  states: {}
- name: movavg_length
  id: variable_qtgui_range
  parameters:
    label: Moving Average Length
    start: '1000'
    step: '1'
    stop: '16383'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25E6
  states: {}
- name: trig_freq
  id: variable_qtgui_range
  parameters:
    label: Trigger Frequency
    start: 8E6
    step: 100E3
    stop: 15E6
    value: 11E6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3999'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: movavg_length
    max_iter: '4000'
    scale: 1/movavg_length
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """ Ionosonde Trigger Block
          By Jaden Keener, 2/5/23
          
          Last updated 2/12/23 2:41
          - Added moving average functionality. Now we shouldn't have to manually set
            trigger threshold
          - TRYING TO FIX WINODW
          
          This block records the raw SDR output when a strong enough input is 
          provided. This block is meant to be used alongside a filter. The filter 
          should bandpass the trigger frequency, then go to an average power block
          which then feeds into this blocks first input.
          
          Outputs are purely debug.
          
          See __init__ for additional i/o information
      """

      import numpy as np
      import datetime
      from gnuradio import gr

      class blk(gr.sync_block):  

          def __init__(self, trigger_delta_dB=5, samp_rate = 32E3, capture_window = 5): 
              
              """ INPUTS/OUTPUTS:
                      input[0]: Signal average power
                      input[1]: Raw data from SDR
                      input[2]: Moving average of [0]
                      
                      output[0]: debug state information
                      output[1]: debug timer information
                  """
              gr.sync_block.__init__(
                  self,
                  name='Ionosonde Trigger 2.0', 
                  in_sig=[np.float32, np.complex64, np.float32],
                  out_sig=[np.float32, np.float32]
              )
              
              self.trigger_Power = trigger_delta_dB
              self.samp_rate = samp_rate
              self.capture_window = capture_window
              # timer max is calculated as sample rate * capture window in seconds.
              self.timerMax = self.timer = self.samp_rate * self.capture_window
              self.writing = False
             

          def work(self, input_items, output_items):
              
              self.power_movavg = input_items[2]
              
              # Check if we are writing
              if self.writing:
                  # If we are and we still have time on the clock
                  if self.timer < self.timerMax:
                      # Then write data to file
                      self.file.write(input_items[1][:])
                      self.timer += len(input_items[1])
                      output_items[0][:] = 2
                  else:
                      # Otherwise close the file and reset flags
                      self.file.close()
                      self.writing = False
                      output_items[0][:] = 0
              
              # If not writing, do we have high power on trigger?
              elif np.any(input_items[0] > self.trigger_Power+self.power_movavg):
                  # Set status variables
                  self.writing = True
                  self.timer = 0
                  output_items[0][:] = 1
                  
                  # Open new file and do first write
                  self.filename = '{date:%Y%m%d_%H%M%S}.chirp'.format(date=datetime.datetime.now())
                  self.file = open(self.filename, "ab")
                  self.file.write(input_items[1][:])
              # Show debug state of none
              else:
                  output_items[0][:] = 0
              
              # For debugging timer
              output_items[1][:] = self.timer
              
              # gnuradio needs this return
              return len(output_items[0])
    capture_window: '5'
    samp_rate: samp_rate
    trigger_delta_dB: '5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    name: '"Power"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '3'
    name: '"TrigOut"'
    type: float
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: 200E3
    min: '0'
    name: '"Timer"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Moving Average"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 17.5E6
    fftsize: '1024'
    int_max: '0'
    int_min: '-100'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: B
    bw0: samp_rate
    center_freq0: 17.5E6
    clock_source0: gpsdo
    gain0: '50'
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_1, '2']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_2, '0']
- [blocks_nlog10_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '0', qtgui_number_sink_1, '0']
- [epy_block_1, '1', qtgui_number_sink_1_1, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', epy_block_1, '1']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
