options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: testbench
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1E3
    step: 1E3
    stop: 10E3
    value: 3E3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32E3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3999'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """ Ionosonde Trigger Block
          By Jaden Keener, 2/5/23
          
          Last updated 2/5/23 19:42
          
          This block records the raw SDR output when a strong enough input is 
          provided. This block is meant to be used alongside a filter. The filter 
          should bandpass the trigger frequency, then go to an average power block
          which then feeds into this blocks first input.
          
          Outputs are purely debug.
          
          See __init__ for additional i/o information
      """

      import numpy as np
      import datetime
      from gnuradio import gr

      class blk(gr.sync_block):  

          def __init__(self, trigger_Power=0.5, samp_rate = 32E3, capture_window = 5): 
              
              """ INPUTS/OUTPUTS:
                      input[0]: Signal average power
                      input[1]: Raw data from SDR
                      
                      output[0]: debug state information
                      output[1]: debug timer information
                  """
              gr.sync_block.__init__(
                  self,
                  name='Ionosonde Trigger', 
                  in_sig=[np.float32, np.complex64],
                  out_sig=[np.int8, np.float32]
              )
              
              self.trigger_Power = trigger_Power
              self.samp_rate = samp_rate
              self.capture_window = capture_window
              # timer max is calculated as sample rate * capture window in seconds.
              self.timerMax = self.timer = self.samp_rate * self.capture_window
              self.writing = False
             

          def work(self, input_items, output_items):
              
              # Check if we are writing
              if self.writing:
                  # If we are and we still have time on the clock
                  if self.timer < self.timerMax:
                      # Then write data to file
                      self.file.write(input_items[1][:])
                      self.timer += len(output_items[0])
                      output_items[0][:] = 2
                  else:
                      # Otherwise close the file and reset flags
                      self.file.close()
                      self.writing = False
                      output_items[0][:] = 0
              
              # If not writing, do we have high power on trigger?
              elif np.any(input_items[0] > self.trigger_Power):
                  # Set status variables
                  self.writing = True
                  self.timer = 0
                  output_items[0][:] = 1
                  
                  # Open new file and do first write
                  self.filename = '{date:%Y%m%d_%H%M%S}.chirp'.format(date=datetime.datetime.now())
                  self.file = open(self.filename, "ab")
                  self.file.write(input_items[1][:])
              # Show debug state of none
              else:
                  output_items[0][:] = 0
              
              # For debugging timer
              output_items[1][:] = self.timer
              
              # gnuradio needs this return
              return len(output_items[0])
    capture_window: '5'
    samp_rate: samp_rate
    trigger_Power: '0.5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    name: '"Power"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '3'
    name: '"TrigOut"'
    type: byte
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: 200E3
    min: '0'
    name: '"Timer"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Raw"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', epy_block_1, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', qtgui_number_sink_1, '0']
- [epy_block_1, '1', qtgui_number_sink_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
